<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>trickling_items_trickle_src</key>
<param><key>id</key><value>trickling_items_trickle_src_0</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>trickling_demo</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>trickling_items_trickle_sink</key>
<param><key>id</key><value>trickling_items_trickle_sink_0</value></param>
</block>
<connection><source_block_id>trickling_items_trickle_src_0</source_block_id><sink_block_id>trickling_items_trickle_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
